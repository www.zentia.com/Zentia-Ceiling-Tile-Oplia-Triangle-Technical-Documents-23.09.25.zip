Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-09-04T12:40:19
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_OpliaTriangle, Compound Ceiling:NBS_Zentia_ModularSuspendedCeilingSystems_OpliaTriangle:222062
In: Level 0
Type - PredefinedType: CEILING
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: CEILING
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Ss_30_25_22_51:Modular suspended ceiling systems; Color: n/a; Finish: Painted; Material: Mineral fibre; Shape: Triangle; Size: n/a; WarrantyDescription: 30 year; CodePerformance: n/a; Constituents: n/a; Description: Oplia Triangle suspended ceiling tiles are cut into an equilateral triangle shape, allowing you add a very different visual effect to your suspended ceiling design.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@zentia.com; ModelNumber: n/a; ModelReference: Oplia Triangle; Name: ModularSuspendedCeilingSystems_OpliaTriangle_Zentia; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Zentia_ModularSuspendedCeilingSystems_OpliaTriangle; ManufacturerName: Zentia; ManufacturerURL: https://www.zentia.com; ProductInformation: https://source.thenbs.com/product/-/8e1a916e-e8f1-4538-bfa5-b6e8cca6d832/44fd8f6e-21f2-44c9-a898-788199e8aa27; Uniclass2015Code: Ss_30_25_22_51; Uniclass2015Title: Modular suspended ceiling systems; Uniclass2015Version: Systems v1.37; Version: 4
Type - NBS_Data - CeilingSupport: Gridline 24 joggled/butt cut, Global White,Gridline 24 joggled/butt cut, Black; CeilingUnits: 1200 x 1200 x 1200 x 17 mm board edge mineral tiles, Global White (BPTT2802M),1200 x 1200 x 1200 x 17 mm board edge mineral tiles, other colour; SamplesRequired: Product samples,Not required; ContainsRedListMaterials: No; CountryOfMaterialOrigin: Europe; CountryOfProductManufacture: United Kingdom; Recyclability: 100; RecycledContent: 80; Weight: 4.6 kg/m²; ReactionToFire: To EN 13501-1, infill units: Euroclass A2-s1, d0.Support grid: Euroclass A1; NoiseReductionCoefficient: Infill units: 0.65(H); FormaldehydeEmissions: Infill units: To EN 13964, formaldehyde emission level E1 = Best test result possible; ColourLightReflectanceValueLRV: Infill units: 85% (Global White); RelativeHumidity: Infill units: 95%
Classification: Ss_30_25_22_51 (Uniclass2015); Material: NBS_Zentia_ModularSuspendedCeilingSystems_OpliaTriangle 17 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
